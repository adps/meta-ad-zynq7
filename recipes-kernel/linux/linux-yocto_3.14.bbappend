
require linux-machine-common.inc

COMPATIBLE_MACHINE_zynq = "zynq"

